File: kicad/Dusk 36.kicad_pcb (KiCad board)
At the start: 2 copper layers, 124.2 x 100.8 mm, 63 parts

Commit message: Rename board to Dusk 36
Parts:
- G*** (x2): footprint libs:dusk -> Dusk 36:dusk
